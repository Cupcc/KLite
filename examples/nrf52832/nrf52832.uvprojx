# Keil uVision project nrf52832.uvprojx, settings and files
target nrf52832 (5060960::V5.06 update 7 (build 960)::.\ArmCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT
  c include: .\Sources\sdk\;.\Sources\sdk\components;.\Sources\sdk\components\ble\ble_advertising;.\Sources\sdk\components\ble\ble_link_ctx_manager;.\Sources\sdk\components\ble\ble_racp;.\Sources\sdk\components\ble\ble_services\ble_dis;.\Sources\sdk\components\ble\ble_services\ble_nus;.\Sources\sdk\components\ble\ble_services\ble_bas;.\Sources\sdk\components\ble\common;.\Sources\sdk\components\ble\nrf_ble_gatt;.\Sources\sdk\components\ble\nrf_ble_qwr;.\Sources\sdk\components\ble\peer_manager;.\Sources\sdk\components\libraries\atomic;.\Sources\sdk\components\libraries\atomic_fifo;.\Sources\sdk\components\libraries\atomic_flags;.\Sources\sdk\components\libraries\balloc;.\Sources\sdk\components\libraries\bootloader\ble_dfu;.\Sources\sdk\components\libraries\bsp;.\Sources\sdk\components\libraries\button;.\Sources\sdk\components\libraries\cli;.\Sources\sdk\components\libraries\crc16;.\Sources\sdk\components\libraries\crc32;.\Sources\sdk\components\libraries\crypto;.\Sources\sdk\components\libraries\csense;.\Sources\sdk\components\libraries\csense_drv;.\Sources\sdk\components\libraries\delay;.\Sources\sdk\components\libraries\ecc;.\Sources\sdk\components\libraries\experimental_section_vars;.\Sources\sdk\components\libraries\experimental_task_manager;.\Sources\sdk\components\libraries\fds;.\Sources\sdk\components\libraries\fifo;.\Sources\sdk\components\libraries\fstorage;.\Sources\sdk\components\libraries\gfx;.\Sources\sdk\components\libraries\gpiote;.\Sources\sdk\components\libraries\hardfault;.\Sources\sdk\components\libraries\hci;.\Sources\sdk\components\libraries\led_softblink;.\Sources\sdk\components\libraries\log;.\Sources\sdk\components\libraries\log\src;.\Sources\sdk\components\libraries\low_power_pwm;.\Sources\sdk\components\libraries\mem_manager;.\Sources\sdk\components\libraries\memobj;.\Sources\sdk\components\libraries\mpu;.\Sources\sdk\components\libraries\mutex;.\Sources\sdk\components\libraries\pwm;.\Sources\sdk\components\libraries\pwr_mgmt;.\Sources\sdk\components\libraries\queue;.\Sources\sdk\components\libraries\ringbuf;.\Sources\sdk\components\libraries\scheduler;.\Sources\sdk\components\libraries\sdcard;.\Sources\sdk\components\libraries\slip;.\Sources\sdk\components\libraries\sortlist;.\Sources\sdk\components\libraries\spi_mngr;.\Sources\sdk\components\libraries\stack_guard;.\Sources\sdk\components\libraries\strerror;.\Sources\sdk\components\libraries\svc;.\Sources\sdk\components\libraries\timer;.\Sources\sdk\components\libraries\twi_mngr;.\Sources\sdk\components\libraries\twi_sensor;.\Sources\sdk\components\libraries\uart;.\Sources\sdk\components\libraries\util;.\Sources\sdk\components\softdevice\common;.\Sources\sdk\components\softdevice\s132\headers;.\Sources\sdk\components\softdevice\s132\headers\nrf52;.\Sources\sdk\components\toolchain\cmsis\include;.\Sources\sdk\external\fprintf;.\Sources\sdk\external\segger_rtt;.\Sources\sdk\integration\nrfx;.\Sources\sdk\integration\nrfx\legacy;.\Sources\sdk\modules\nrfx;.\Sources\sdk\modules\nrfx\drivers\include;.\Sources\sdk\modules\nrfx\hal;.\Sources\sdk\modules\nrfx\mdk;..\..\sources\kernel;..\..\sources\opt
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002ad8 size 0xd528
  group Application
    ./Sources/main/: main.c daemon.c app.c
  group nRF_BLE
    ./Sources/sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ./Sources/sdk/components/ble/ble_advertising/: ble_advertising.c
    ./Sources/sdk/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ./Sources/sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ./Sources/sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ./Sources/sdk/components/ble/ble_services/ble_nus/: ble_nus.c
    ./Sources/sdk/components/ble/ble_services/ble_dis/: ble_dis.c
    ./Sources/sdk/components/ble/ble_services/ble_bas/: ble_bas.c
  group nRF_Drivers
    ./Sources/sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ./Sources/sdk/modules/nrfx/soc/: nrfx_atomic.c
    ./Sources/sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ./Sources/sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ./Sources/sdk/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./Sources/sdk/components/libraries/fifo/: app_fifo.c
    ./Sources/sdk/components/libraries/scheduler/: app_scheduler.c
    ./Sources/sdk/components/libraries/uart/: app_uart_fifo.c
    ./Sources/sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ./Sources/sdk/components/libraries/atomic_flags/: nrf_atflags.c
    ./Sources/sdk/components/libraries/atomic/: nrf_atomic.c
    ./Sources/sdk/components/libraries/balloc/: nrf_balloc.c
    ./Sources/sdk/components/libraries/memobj/: nrf_memobj.c
    ./Sources/sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ./Sources/sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    ./Sources/sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./Sources/sdk/components/libraries/sortlist/: nrf_sortlist.c
    ./Sources/sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./Sources/sdk/components/libraries/strerror/: nrf_strerror.c
    ./Sources/sdk/components/libraries/timer/: app_timer_rtos.c
  group nRF_Log
    ./Sources/sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ./Sources/sdk/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ./Sources/sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c nrf_sdh_rtos.c
  group nRF_CMSIS
    ./Sources/sdk/modules/nrfx/mdk/: system_nrf52.c arm_startup_nrf52.s
  group kernel
    ../../sources/kernel/: cond.c event.c heap.c kernel.c mutex.c sched.c sem.c thread.c
  group port
    ../../sources/port/cortex-m4/: cpu.c nrf52832.c cpu_asm_keil.s
  group opt
    ../../sources/opt/: stimer.c
