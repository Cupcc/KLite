# Keil uVision project stm32f103.uvprojx, settings and files
target stm32f103 (5060960::V5.06 update 7 (build 960)::.\ArmCC)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources;.\Sources\cmsis;..\..\sources\kernel
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group main
    ./Sources/: app.c bsp.c main.c
  group kernel
    ../../sources/kernel/: cond.c event.c heap.c kernel.c mutex.c sched.c sem.c thread.c
  group port
    ../../sources/port/cortex-m3/: cpu.c cmsis.c cpu_asm_keil.s
  group cmsis
    ./Sources/cmsis/: system_stm32f10x.c startup_stm32f10x_hd.s
