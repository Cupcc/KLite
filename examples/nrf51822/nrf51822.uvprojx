# Keil uVision project nrf51822.uvprojx, settings and files
target nrf51822 (5060960::V5.06 update 7 (build 960)::.\ArmCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources;.\Sources\cmsis;..\..\sources\kernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./Sources/: app.c bsp.c main.c
  group kernel
    ../../sources/kernel/: cond.c event.c heap.c kernel.c mutex.c sched.c sem.c thread.c
  group port
    ../../sources/port/cortex-m0/: cpu.c cpu_asm_keil.s nrf51822.c
  group cmsis
    ./Sources/cmsis/: system_nrf51.c arm_startup_nrf51.s
