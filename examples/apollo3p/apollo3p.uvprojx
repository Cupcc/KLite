# Keil uVision project apollo3p.uvprojx, settings and files
target apollo3p (5060960::V5.06 update 7 (build 960)::.\ArmCC)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IROM(0x0000C000,0x001F4000) IRAM(0x10000000,0x000C0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: klite
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Sources\;.\Sources\cmsis;..\..\sources\kernel
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  group main
    ./Sources/: bsp.c app.c main.c
  group kernel
    ../../sources/kernel/: cond.c event.c heap.c kernel.c mutex.c sched.c sem.c thread.c
  group port
    ../../sources/port/cortex-m4/: cpu.c cpu_asm_keil.s apollo3p.c
  group cmsis
    ./Sources/cmsis/: system_apollo3p.c startup_apollo3p.s
