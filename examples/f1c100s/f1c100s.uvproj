# Keil uVision project f1c100s.uvproj, settings and files
target F1C100S (5060960::V5.06 update 7 (build 960)::.\ArmCC)
  device: ARM926EJ-S ARM9
  cpu: CLOCK(60000000) CPUTYPE(ARM926EJ-S)
  output: f1c100s
  AfterMake: fromelf.exe --bin -o "$P@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources;..\..\sources\kernel;..\..\sources\port\arm9\common;..\..\sources\port\arm9\f1c100s
  memory RVCT4: ROM 0x80000000 size 0x100000
  memory RVCT9: RAM 0x80100000 size 0x100000
  group demo
    ./Sources/: main.c bsp.c app.c
  group kernel
    ../../sources/kernel/: cond.c event.c heap.c kernel.c mutex.c sched.c sem.c thread.c
  group opt
    ../../sources/opt/: fifo.c soft_timer.c event_group.c byte_stream.c mem_pool.c blk_queue.c msg_queue.c
  group port
    ../../sources/port/arm9/f1c100s/: cpu.c intc.c
    ../../sources/port/arm9/common/: arm.c start.s irq.s
