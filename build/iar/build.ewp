# IAR project build.ewp, settings and files
configuration cortex-cm0 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\sources\kernel\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: build.out
configuration cortex-cm3 (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
configuration cortex-cm4 (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  group kernel
    ../../sources/kernel/: event.c heap.c kernel.c mutex.c sched.c sem.c thread.c
  group port/cortex-m0
    ../../sources/arch/cortex-m0/: cpu.c cpu_asm_iar.s
  group port/cortex-m3
    ../../sources/arch/cortex-m3/: cpu.c cpu_asm_iar.s
  group port/cortex-m4
    ../../sources/arch/cortex-m4/: cpu.c cpu_asm_iar.s
