# Keil uVision project demo.uvprojx, settings and files
target hc32f460 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HC32F460JCTA HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IROM(0x00000000,0x40000) IROM2(0x03000C00,0x003FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\cpu;.\Sources\cpu\cmsis;.\Sources\main;..\..\sources\kernel;..\..\sources\misc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group main
    ./Sources/main/: main.c demo.c
  group kernel
    ../../sources/kernel/: event.c heap.c kernel.c mutex.c sched.c thread.c sem.c
  group port
    ../../sources/arch/cortex-m4/: cpu.c cpu_asm_keil.s
    ../../sources/port/: hc32f460.c
  group cpu
    ./Sources/cpu/: system_hc32f460.c startup_hc32f460.s
